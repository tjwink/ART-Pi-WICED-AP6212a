# Keil uVision project Fire_H7.uvprojx, settings and files
target AP6181 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: F429
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER,STM32H743xx,DEBUG
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\WWD\include;..\..\WWD;..\..\WWD\internal\bus_protocols\SDIO;..\..\WWD\internal;..\..\WWD\net;..\..\WWD\internal\chips\43362;..\..\WWD\include\RTOS;..\..\WWD\canned_send;..\..\WWD\network;..\..\WWD\platform;..\..\WWD\RTOS;..\..\WWD\sdio_driver;..\..\WWD\utilities;..\..\WWD\include\debug;..\..\WWD\include\network;..\..\WWD\include\platform;..\..\WWD\include\WICED
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_cortex.c stm32h7xx_ll_sdmmc.c
  group USER
    ../../User/: main.c stm32h7xx_it.c
    ../../User/usart/: bsp_debug_usart.c
    ../../User/led/: bsp_led.c
  group Wifi
    ../../WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c
    ../../WWD/internal/bus_protocols/: wwd_bus_common.c
    ../../WWD/internal/chips/43362/: wwd_chip_specific_functions.c wwd_ap.c
    ../../WWD/internal/: wwd_internal.c wwd_sdpcm.c wwd_thread_internal.c wwd_thread.c wwd_management.c wwd_ap_common.c wwd_wifi.c
    ../../WWD/network/: wwd_buffer.c
    ../../WWD/RTOS/: noos.c wwd_rtos.c
    ../../WWD/utilities/: tlv.c
    ../../WWD/platform/: platform_resource.c wwd_resources.c
    ../../WWD/sdio_driver/: 43362A2_bin.c wlan_bus_sdio.c
  group DOC
    ../../: 必读说明.txt
